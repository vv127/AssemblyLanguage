# Keil uVision project arm_asm_expr.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM966E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S) EBIG
  output: arm_asm_expr
  c flags: Optim=1
  group Source Group 1
    ./: Experiment3.s
